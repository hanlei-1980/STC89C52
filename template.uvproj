# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app\24c02;.\app\iic;.\app\key;.\app\smg;.\public;.\app\ired;.\app\ds18b20;.\app\uart;
  group user
    ./user/: main.c
  group app
    ./app/24c02/: 24c02.c
    ./app/iic/: iic.c
    ./app/key/: key.c
    ./app/smg/: smg.c
    ./app/ired/: ired.c
    ./app/ds18b20/: ds18b20.c
    ./app/uart/: uart.c
  group public
    ./public/: public.c
